# Keil uVision project 红外通信.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 红外通信 +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c
  group interrupt_set
    ./: interrupt_set.c interrupt_set.h
  group delay
    ./: delay.c delay.h
  group PWM_out
    ./: PWM_OUT.c PWM_OUT.h
  group MOTOR
    ./: motor.c motor.h
