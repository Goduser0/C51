# Keil uVision project PWM_motor.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: PWM_motor +hex
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: main.c
  group delay
    ./: delay.c delay.h
  group interrupt_set
    ./: exit_set.c exit_set.h
